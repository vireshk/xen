## xen/arch/arm/configs/arm64_defconfig
```kconfig
CONFIG_IOREQ_SERVER=y
CONFIG_EXPERT=y
CONFIG_TESTS=y
CONFIG_TEE=y
CONFIG_UNSUPPORTED=y
CONFIG_FFA=y
CONFIG_FFA_VM_TO_VM=y
```
